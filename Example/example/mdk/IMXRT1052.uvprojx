# Keil uVision project IMXRT1052.uvprojx, settings and files
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.11.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: IMXRT1052.out
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186 
--diag_suppress=1296,186
  c include: ..\..\example;..\..\..\CMSIS\Include;..\..\..\Device\board;..\..\..\Device\drivers\LQRT1052;..\..\..\Device\drivers\MIMXRT1052;..\..\..\Device\drivers\MIMXRT1052\camera;..\..\..\Device\startup\iar;..\..\..\Device\utilities;..\..\..\Device\xip;..\..\..\Device;..\sd;..\..\..\Device\fatfs\fatfs\source;..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk;..\..\..\Device\fatfs\sdmmc\inc
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: main.c include.h include_all.h irq.c
  group board
    ../../../Device/board/: board.c clock_config.c pin_mux.c
  group lq
    ../../../Device/drivers/LQRT1052/: LQ_LED.c LQ_GPIO.c ANO_DT.c ICM20602_SOFTSPI.c LQ_9AX.c LQ_12864SPI.c LQ_ADC.c LQ_Camera.c LQ_CSI.c LQ_DMA.c LQ_Encoder.c LQ_FLASH.c LQ_GPT.c LQ_ICM20602.c LQ_IIC.c LQ_KEY.c LQ_MPU6050.c LQ_MT9V034M.c LQ_OV7725M.c LQ_PIT.c LQ_PWM.c LQ_QTMR.c LQ_Rtwdog.c LQ_SGP18T.c LQ_SOFTIIC.c LQ_SPI.c LQ_SYSTICK.c LQ_Tempmon.c LQ_TRNG.c LQ_UART.c LQ_UART_DMA.c LQ_Ultrasonic.c LQ_VL53.c LQ_W25Q128.c LQ_WDog.c LQ_SDCard.c
  group drivers
    ../../../Device/drivers/MIMXRT1052/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_adc.c fsl_cache.c fsl_csi.c fsl_dmamux.c fsl_edma.c fsl_enc.c fsl_flexspi.c fsl_gpt.c fsl_lpi2c.c fsl_lpspi.c fsl_lpuart_edma.c fsl_pit.c fsl_qtmr.c fsl_rtwdog.c fsl_tempmon.c fsl_trng.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_pwm.c
    ../../../Device/drivers/MIMXRT1052/camera/: fsl_csi_camera_adapter.c fsl_sccb.c
  group startup
    ../../../Device/: system_MIMXRT1052.c
    ../../../Device/startup/arm/: startup_MIMXRT1052_mdk.s
  group utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_str.c lpuart_adapter.c serial_manager.c serial_port_uart.c
  group xip
    ../../../Device/xip/: fsl_flexspi_nor_boot.c xip_config.c
  group doc
    ../: readme.txt
  group fatfs
    ../../../Device/fatfs/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../Device/fatfs/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
  group sdmmc
    ../sd/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../Device/fatfs/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
