# IAR project Backup of IMXRT1052.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; LQRELEASE; DEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pe167, Pa082
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\board; ..\..\..\Device\drivers\LQRT1052; ..\..\..\Device\drivers\MIMXRT1052; ..\..\..\Device\drivers\MIMXRT1052\camera; ..\..\..\Doc; ..\..\..\Device\startup\iar; ..\..\..\Device\utilities; ..\..\..\Device\xip; ..\..\..\Device; ..\..\..\Device\fatfs\fatfs\source; ..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk; ..\..\..\Device\fatfs\sdmmc\inc; ..\sd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: LQ_LED.srec
  ILINK.IlinkOutputFile: LQ_LED.out
  ILINK.IlinkIcfFile: LQ_RT1052QSPI_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../Device/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../Device/drivers/MIMXRT1052/: fsl_adc.c fsl_adc.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
    ../../../Device/drivers/MIMXRT1052/camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_sccb.c fsl_sccb.h fsl_video_common.h
  group fatfs
    ../../../Device/fatfs/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c integer.h
    ../../../Device/fatfs/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group lq
    ../../../Device/drivers/LQRT1052/: ANO_DT.c ANO_DT.h ICM20602_SOFTSPI.c ICM20602_SOFTSPI.h LQ_12864.h LQ_12864SPI.c LQ_9AX.c LQ_9AX.h LQ_ADC.c LQ_ADC.h LQ_Camera.c LQ_Camera.h LQ_CSI.c LQ_CSI.h LQ_Encoder.c LQ_Encoder.h LQ_FLASH.c LQ_FLASH.h LQ_GPIO.c LQ_GPIO.h LQ_GPIO_Cfg.h LQ_GPT.c LQ_GPT.h LQ_ICM20602.c LQ_ICM20602.h LQ_IIC.c LQ_IIC.h LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_MPU6050.c LQ_MPU6050.h LQ_MT9V034M.c LQ_MT9V034M.h LQ_OV7725M.c LQ_OV7725M.h LQ_PIT.c LQ_PIT.h LQ_PWM.c LQ_PWM.h LQ_QTMR.c LQ_QTMR.h LQ_Rtwdog.c LQ_Rtwdog.h LQ_SDCard.c LQ_SDCard.h LQ_SGP18T.c LQ_SGP18T.h LQ_SOFTIIC.c LQ_SOFTIIC.h LQ_SPI.c LQ_SPI.h LQ_SYSTICK.c LQ_SYSTICK.h LQ_Tempmon.c LQ_Tempmon.h LQ_TRNG.c LQ_TRNG.h LQ_UART.c LQ_UART.h LQ_UART_DMA.c LQ_UART_DMA.h LQ_Ultrasonic.c LQ_Ultrasonic.h LQ_VL53.c LQ_VL53.h LQ_W25Q128.c LQ_W25Q128.h LQ_WDog.c LQ_WDog.h
  group sdmmc
    ../../../Device/fatfs/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../../../Device/fatfs/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../sd/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group source
    ../sd/: ffconf.h
    ../: include.h include_all.h irq.c main.c
  group startup
    ../../../Device/startup/iar/: startup_MIMXRT1052_iar.s
    ../../../Device/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h lpuart_adapter.c serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h uart.h
  group xip
    ../../../Device/xip/: external_flash_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h xip_config.c
